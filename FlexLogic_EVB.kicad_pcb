# Repository y-suyama/FlexLogic_EVB

## KiCad design FlexLogic_EVB.kicad_pcb

Parts (part):
C1, C6, C8, C9, C10, C11, C12, C13, C14, C23, C31, C34, C35, C37, C38, C39, C40, C41, C42, C43, C44, C45, C46, C50, C51, C53, C55, C56, C57, C58, C59, C60, C61, C62, C63, C64, C65, C67, C69, C70, C71, C77, C82, C83, C84, C86, C87, C89, C90, C92, C93, C109, C110, C111, C112, C113, C118, C119, C120, C121, C122, C123, C124, C125, C126, C127, C128, C129, C130, C131, C132: 0.1uF; C_0201_0603Metric_Pad0.64x0.40mm_HandSolder; MANUFACTURER_PART_NUMBER GRM033R61E104KE14D; JLCPCB C76939
C2, C7, C15, C16, C17, C68: 10uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder; MANUFACTURER_PART_NUMBER HGC0402R5106M100NTEJ; JLCPCB C7472949
C3, C4, C5, C20: 22uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MANUFACTURER_PART_NUMBER HGC0603R5226M100NTHJ; JLCPCB C7432770
C18, C19, C47, C48, C72, C73: 30pF; C_0201_0603Metric_Pad0.64x0.40mm_HandSolder; MANUFACTURER_PART_NUMBER TCC0201COG300J500ZT; JLCPCB C5142545
C24, C25, C79, C94, C107: 0.01uF; C_0201_0603Metric_Pad0.64x0.40mm_HandSolder
C32, C52: 0.01uF; C_0201_0603Metric_Pad0.64x0.40mm_HandSolder; MANUFACTURER_PART_NUMBER 0201B103K250NT; JLCPCB C285010
C33: 1uF; C_0402_1005Metric; MANUFACTURER_PART_NUMBER TCC0402X5R105M6R3AT; JLCPCB C2887021
C36, C49, C54, C66, C74, C85, C88, C91: 1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder; MANUFACTURER_PART_NUMBER TCC0402X5R105M6R3AT; JLCPCB C2887021
C75, C95, C96, C97, C98, C99, C100, C103, C104, C105, C106, C108: 0.1uF; C_0201_0603Metric_Pad0.64x0.40mm_HandSolder
C101, C102: 1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C114, C115: 4.7uF; C_0402_1005Metric_small_pads; MANUFACTURER_PART_NUMBER 0402X475K100NT; JLCPCB C191541
C116, C117: 4.7uF; C_0402_1005Metric; MANUFACTURER_PART_NUMBER 0402X475K100NT; JLCPCB C191541
D1: LESD5D5-0CT1G; D_SOD-523; MANUFACTURER_PART_NUMBER LESD5D5.0CT1G-ES; JLCPCB C5199159
D2: XL-1005UBC; LED_0402_1005Metric_Pad0.77x0.64mm_HandSolder; MANUFACTURER_PART_NUMBER XL-1005UBC; JLCPCB C22355736
D3, D4, D5, D6, D7: TT0401TBX; DFN-2L; JLCPCB C5380463
H1, H2, H3, H5: MountingHole; MountingHole_3.2mm_M3_Pad_Via
IC1: MT9700; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR; MANUFACTURER_PART_NUMBER MT9700; JLCPCB C42441843
IC2: SL2.1s; SSOP-16_L4.6-W2.6-P0.53-LS4.0-BL; MANUFACTURER_PART_NUMBER SL2.1S; JLCPCB C2684433
IC4: LCMXO2-1200HC-4SG32I; QFN50P500X500X60-33N_handsolder; Manufacturer_Part_Number LCMXO2-1200HC-4SG32I; Mouser Part Number 842-MXO21200HC4SG32I
IC5: MTS4P; MANUFACTURER_PART_NUMBER MTS4P; JLCPCB C19284877
IC6: XT25F32FDTIGT; SON50P300X200X60-9N_handsolder; MANUFACTURER_PART_NUMBER XT25F32FDTIGT
J1: GT-USB-7010ASV; USB-C-SMD_G-SWITCH_GT-USB-7010ASV; MANUFACTURER_PART_NUMBER GT-USB-7010ASV; JLCPCB C2988369
J2, J3, J4, J5: WJ126V-5.0-2P; MANUFACTURER_PART_NUMBER WJ126V-5.0-2P; JLCPCB C8404
J6, J7, J8, J9, J11: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J12: 1.0-3PWB; MANUFACTURER_PART_NUMBER 1.0-3PWB; JLCPCB C2905005
J13: HB9500M-9.5-4P; CONN_HB9500-9.5-4P_KAN
J14: TF-CARD_H1.8_SY; JLCPCB C7529391
J15: HC-FPC-0.5-12P-CXH20
L1, L2, L4, L5, L6, L7, L8, L9: HCB1005KF-121T20; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder; MANUFACTURER_PART_NUMBER HCB1005KF-121T20; JLCPCB C141722
L3: 1.5uH; FTC252012S1R5MBCA; MANUFACTURER_PART_NUMBER FTC252012S1R5MBCA; JLCPCB C5832371
L10: 3.3uH; AOTA-B201610S3R3-101-T; JLCPCB C42411119
Q1, Q2, Q4: L2N7002SLLT1G; SOT-23_Handsoldering; JLCPCB C22446827
R1, R12, R23, R66: 10k; R_0201_0603Metric_Pad0.64x0.40mm_HandSolder
R2, R5, R13, R26, R27, R29, R36, R100, R102, R111: 4.7k; R_0201_0603Metric_Pad0.64x0.40mm_HandSolder; MANUFACTURER_PART_NUMBER 0201WMF4701TEE; JLCPCB C270346
R3, R24, R25, R48, R50, R51, R53, R55, R56, R58, R60, R63, R64, R86, R88, R89, R90, R91, R92, R101, R105, R107, R108, R112, R113, R114: 10k; R_0201_0603Metric_Pad0.64x0.40mm_HandSolder; MANUFACTURER_PART_NUMBER RC0201FR-0710KL; JLCPCB C106225
R4: 100k; R_0201_0603Metric_Pad0.64x0.40mm_HandSolder; MANUFACTURER_PART_NUMBER RC-01W104JT; JLCPCB C304505
R6, R87, R99: 1k; R_0201_0603Metric_Pad0.64x0.40mm_HandSolder; MANUFACTURER_PART_NUMBER RC0201FR-071KL; JLCPCB C138165
R7: 3.6k; R_0201_0603Metric_Pad0.64x0.40mm_HandSolder; MANUFACTURER_PART_NUMBER WR02X362JAL; JLCPCB C367600
R8: 22k; R_0201_0603Metric_Pad0.64x0.40mm_HandSolder; MANUFACTURER_PART_NUMBER 0201WMF2202TEE; JLCPCB C473469
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
Connections (part):
+1.1V_MCU: C115.1, C117.1, C118.1, C119.1, L10.1, U11.6 (DVDD), U11.23 (DVDD), U11.39 (DVDD), U11.50 (VREG_FB)
+3.3V: C5.1, C11.1, C13.1, C82.1, L3.2, L4.1, L5.1, L6.1, L7.1, L8.1, R4.2
+3.3V_ADC: C8.1, C14.1, C31.1, C32.1, C51.1, C52.1, IC5.3 (VDD), L8.2, R16.1, R30.1, R37.1, R42.1, R58.1, U4.8 (VDD), U7.8 (VDD)
+3.3V_A_FT2232H: C12.1, C63.1, C64.1, L7.2, U8.4 (VPHY), U8.9 (VPLL)
+3.3V_D: C23.1, C33.2, C34.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C114.1, C121.1, C122.1, C123.1, C124.1, C125.1, C126.1, C127.1, C128.1, C129.1, C130.1, C131.1, C132.1, IC4.2 (VCC_1), IC4.6 (VCCIO3), IC4.7 (VCCIO2_1), IC4.15 (VCCIO2_2), IC4.18 (VCC_2), IC4.19 (VCCIO1), IC4.24 (VCCIO0_1), IC4.31 (VCCIO0_2), IC6.8 (VCC), J14.4 (VDD), J15.8, J15.9, L4.2, Q1.1 (G), Q4.1 (G), R3.1, R17.1, R18.1, R24.1, R25.1, R26.1, R27.1, R28.1, R29.1, R49.1, R63.1, R64.1, R93.1, R98.1, R102.2, R104.1, R107.1, R108.1, R111.1, R112.1, R113.1, R114.1, U11.1 (IOVDD), U11.11 (IOVDD), U11.20 (IOVDD), U11.30 (IOVDD), U11.38 (IOVDD), U11.44 (ADC_AVDD), U11.45 (IOVDD), U11.49 (VREG_VIN), U11.53 (USB_OTP_VDD), U11.54 (QSPI_IOVDD); also elsewhere on the board
+3.3V_FT2232H: C59.1, C60.1, C61.1, C62.1, C70.1, C71.1, L6.2, R2.1, R13.1, R48.1, R50.1, R51.1, R53.1, R55.1, R56.1, U8.20 (VCCIO), U8.31 (VCCIO), U8.42 (VCCIO), U8.50 (VREGIN), U8.56 (VCCIO), U9.6 (VCC)
+3.3V_WIFI: C83.1, C113.1, L5.2, R86.1, R87.1, R88.1, R89.1, R90.1, R91.1, U13.8 (VCC)
+5V_FIL: C75.1, C79.1, C94.1, C95.1, C96.1, C97.1, C98.1, C99.1, C100.1, C107.1, C108.1, C110.1, L9.2, R109.1, R110.1, U14.3 (VDD), U15.8 (VCC), U16.8 (VCC), U19.5 (V+), U20.5 (V+), U21.8 (VDD), U22.5 (V+), U23.5 (V+)
/D_N: IC2.5 (UDM), J1.A7 (DN1), J1.B7 (DN2)
/D_P: IC2.6 (UDP), J1.A6 (DP1), J1.B6 (DP2)
/FT2232H_N: R46.2, U8.7 (DM)
/FT2232H_P: R47.2, U8.8 (DP)
/JTAG Select/TCK_FT2232H: U8.16 (ADBUS0); also elsewhere on the board
/JTAG Select/TDI_FT2232H: U8.17 (ADBUS1); also elsewhere on the board
/JTAG Select/TDO_FT2232H: U8.18 (ADBUS2); also elsewhere on the board
/JTAG Select/TMS_FT2232H: U8.19 (ADBUS3); also elsewhere on the board
/RP2350A_N: R15.2, U11.51 (USB_DM)
/RP2350A_P: R14.2, U11.52 (USB_DP)
/UART Select/CTS_N_FT2232H: U8.41 (BDBUS3); also elsewhere on the board
/UART Select/RTS_N_FT2232H: R48.2, U8.40 (BDBUS2); also elsewhere on the board
/UART Select/RXD_FT2232H: R51.2, U8.39 (BDBUS1); also elsewhere on the board
/UART Select/TXD_FT2232H: R50.2, U8.38 (BDBUS0); also elsewhere on the board
CARDDET_N: D7.1 (A1), J14.9 (CD), R111.2, U11.31 (GPIO19)
CLK12M: IC4.4 (PL9A), R65.1
CPLD_IO1: IC4.12 (PB9B), J9.1
CPLD_IO2: IC4.13 (PB11A), J9.2
CPLD_IO3: IC4.14 (PB11B), J9.3
CPLD_IO4: IC4.20 (PR5D), J9.4
CPLD_IO5: IC4.21 (PR5C), J9.5
CTS_N_PIN: J7.4; also elsewhere on the board
CTS_N_WIFI: R89.2, U13.7 (GPIO13); also elsewhere on the board
DL_N: C112.1, R91.2, SW3.4, U13.18 (GPIO0)
EVBDET_N: J11.2, U11.40 (GPIO26_ADC0)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.1, C20.2, C23.2, C24.2, C25.2, C31.2, C32.2, C33.1, C34.2, C35.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.1, C48.2, C50.2, C51.2, C52.2, C53.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.1, C73.2, C75.2, C77.2, C79.2, C82.2, C83.2, C84.2, C86.2, C87.2, C89.2, C90.2, C92.2, C93.2, C94.2, C95.2, C96.2, C97.2, C98.2, C99.2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; also elsewhere on the board
I2C0SCL_5V: Q4.3 (D), R110.2, U14.5 (SCL), U21.1 (ADDR), U21.10 (SCL)
I2C0SCL_CUR: Q4.2 (S), R17.2, U11.3 (GPIO1)
I2C0SDA_5V: Q1.3 (D), R109.2, U14.4 (SDA), U21.9 (SDA)
I2C0SDA_CUR: Q1.2 (S), R18.2, U11.2 (GPIO0)
I2C1SCL_TMP: IC5.1 (SCL), R93.2, U4.10 (SCL), U7.10 (SCL), U11.5 (GPIO3)
I2C1SDA_TMP: IC5.4 (SDA), R49.2, U4.9 (SDA), U7.9 (SDA), U11.4 (GPIO2)
IP+_1: J13.1, U16.1 (IP+), U16.2 (IP+)
IP+_2: J13.3, U15.1 (IP+), U15.2 (IP+)
IP-_1: J13.2, U16.3 (IP-), U16.4 (IP-)
IP-_2: J13.4, U15.3 (IP-), U15.4 (IP-)
IRQ_CPLD: IC4.5 (PL9B), R36.1, U11.29 (GPIO18)
JTAG_SEL: R2.2, SW3.2; also elsewhere on the board
LCD_PWM: R106.1, U11.7 (GPIO4)
LogicAna1: J6.1, U11.16 (GPIO12)
LogicAna2: J6.2, U11.17 (GPIO13)
LogicAna3: J6.3, U11.18 (GPIO14)
LogicAna4: J6.4, U11.19 (GPIO15)
MCU_RXD0: R25.2, U11.28 (GPIO17); also elsewhere on the board
MCU_TXD0: R24.2, U11.27 (GPIO16); also elsewhere on the board
unnamed: C35.1, C36.2, R19.2, R38.1
unnamed: C36.1, C45.1, R20.2, R67.1
unnamed: C46.1, C49.2, R31.2, R68.1
unnamed: C49.1, C50.1, R33.2, R69.1
unnamed: C53.1, C54.2, R39.2, R72.1
unnamed: C54.1, C55.1, R40.2, R73.1
unnamed: C65.1, C66.2, R43.2, R74.1
unnamed: C66.1, C67.1, R44.2, R75.1
unnamed: C1.1, D1.1 (A1), J1.A4B9 (VBUS), J1.B4A9 (VBUS), L1.1, R5.1
unnamed: D2.2 (A), R5.2
unnamed: C2.1, IC1.4 (EN), IC1.5 (VIN), L1.2
unnamed: IC1.3 (SET), R7.1
unnamed: C16.1, IC2.10 (VDD18)
unnamed: C15.1, IC2.9 (VDD33)
unnamed: C19.2, IC2.12 (XIN), U3.1 (OSC)
unnamed: C18.1, IC2.11 (XOUT), U3.3 (OSC2)
unnamed: IC4.16 (PB20C), R29.2
unnamed: IC4.26 (PT15C), R26.2
unnamed: IC4.25 (PT15D), R27.2
unnamed: J1.A5 (CC1), R10.1
unnamed: J1.B5 (CC2), R11.1
unnamed: J2.1, R20.1, R21.1
unnamed: J2.2, R16.2, R19.1
unnamed: J3.1, R33.1, R34.1
unnamed: J3.2, R30.2, R31.1
unnamed: J4.1, R40.1, R41.1
unnamed: J4.2, R37.2, R39.1
unnamed: J5.1, R44.1, R45.1
unnamed: J5.2, R42.2, R43.1
unnamed: J11.1, U14.1 (VOUT)
unnamed: J11.3, R97.1
unnamed: J11.4, R96.1
unnamed: J12.1, R62.1
unnamed: J12.3, R70.1
unnamed: C20.1, J15.10, R104.2
unnamed: J15.11, Q2.3 (D)
unnamed: Q2.1 (G), R105.1, R106.2
unnamed: R1.2, R54.2, R76.2, R85.1, U22.4
unnamed: R6.1, SW3.1
unnamed: R9.2, S1.1, S1.2
unnamed: R57.2, R66.2, R78.2, R83.1, U23.4
unnamed: R77.2, R80.2, R84.1, U19.4
unnamed: R79.2, R81.2, R82.1, U20.4
unnamed: R100.1, R101.1, SW1.2
unnamed: R99.1, R100.2, SW1.1
unnamed: R101.2, SW1.3
unnamed: R102.1, R103.2, SW1.4
unnamed: C3.1, C4.1, L2.2, U1.1 (EN), U1.4 (VIN)
unnamed: R4.1, R8.2, U1.5 (FB)
unnamed: L3.1, U1.3 (SW)
unnamed: R60.1, U4.1 (ADDR)
unnamed: C74.2, C77.1, R38.2, U4.4 (AIN0)
unnamed: C74.1, C84.1, R67.2, U4.5 (AIN1)
unnamed: C85.2, C86.1, R68.2, U4.6 (AIN2)
unnamed: C85.1, C87.1, R69.2, U4.7 (AIN3)
unnamed: C48.1, R32.1, U6.3 (OSC2)
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
Notes on the sheet:
DIP SW
UART Pinheader
I/O-VCC
DL_N(ESP-12F)
10Amax
min:3.24V typ:3.33V max:3.42V 1.454Amax
USB2.0 HUB
BOOTSEL
接点位置：ボトム
Power on Reset
200mV/A
DAC 12bit
GND
Slave Address 0x49
SWD Debug
8Pin, 9pinの直近に配置
BOOTSEL(RP2350A)
Global CLK
Current Limit 1.9A(Rset=3.6kΩ)
A方向(4pin to 3pin) = 2.54V[3.3V - 2.2V] 押下 (4pin to 2pin) = 1.8 V[2.1V - 1.2V] B方向(4pin to 1pin) = 0.58V[1.1V - 0V]
typeC
MCU(RP2350A)
80mA 0.025W
Coreless Current Sensors
0.9mΩtyp
CPLD MachXO2 LCMXO2-1200HC-4SG32I
RST
JTAG Pinheader
I2C Level Shift(5V ⇔ 3.3V)
ThermoCouple ADC
Analyzer Pinheader
SCL
LCD仕様 型番 HS20HS072RX ディスプレイサイズ 51.8 mm x 36.2 mm 解像度 320×240ピクセル（QVGA） 表示方式 TFTカラー液晶 制御IC ST7789T3 通信インターフェース SPI 4W 動作温度範囲 -20deg ～ +70deg 接続方法 12ピンFPCコネクタ
USB to UART/JTAG/SPI/I2C(FT2232HL)
Cj = 0.6pF VRWM = 5V VC = 6V
WiFi(ESP-12F)
JTAGSEL(ASW)
UARTSEL(ASW)
VBR=5.6Vmin
60mA
