# Repository y-suyama/FlexLogic_EVB (continued)

## KiCad design FlexLogic_EVB.kicad_pcb (continued)

Parts:
C80: 0.1uF; C_0201_0603Metric_Pad0.64x0.40mm_HandSolder; MANUFACTURER_PART_NUMBER GRM033R61E104KE14D; JLCPCB C76939
U12: TMUX1574DYYR; SOT-23-THIN-16_DYY_TEX; MANUFACTURER_PART_NUMBER TMUX1574DYYR; JLCPCB C1855769

Connections:
+3.3V_D: C80.1, U12.16 (VDD); also elsewhere on the board
/JTAG Select/TCK_FT2232H: U12.4 (D1); also elsewhere on the board
/JTAG Select/TDI_FT2232H: U12.7 (D2); also elsewhere on the board
/JTAG Select/TDO_FT2232H: U12.9 (D3); also elsewhere on the board
/JTAG Select/TMS_FT2232H: U12.12 (D4); also elsewhere on the board
GND: C80.2, U12.8 (GND), U12.15 (*EN); also elsewhere on the board
JTAG_SEL: U12.1 (SEL); also elsewhere on the board
TCK_CPLD: U12.3 (S1B); also elsewhere on the board
TCK/SWCLK_PIN: U12.2 (S1A); also elsewhere on the board
TDI_CPLD: U12.6 (S2B); also elsewhere on the board
TDI/SWDIO_PIN: U12.5 (S2A); also elsewhere on the board
TDO_CPLD: U12.10 (D3B); also elsewhere on the board
TDO_PIN: U12.11 (D3A); also elsewhere on the board
TMS_CPLD: U12.13 (S4B); also elsewhere on the board
TMS_PIN: U12.14 (S4A); also elsewhere on the board

Notes on the sheet:
SEL, *EN Weak pull down:6MΩ(typ)
JTAG Select
1(default)
CPLD
JTAG_SEL(DPSW 2)
接続先
PIN Header
Charge Injection:3.5pC(typ)

Parts:
C21, C22: 0.1uF; C_0201_0603Metric_Pad0.64x0.40mm_HandSolder; MANUFACTURER_PART_NUMBER GRM033R61E104KE14D; JLCPCB C76939
U5, U17: TMUX1574DYYR; SOT-23-THIN-16_DYY_TEX; MANUFACTURER_PART_NUMBER TMUX1574DYYR; JLCPCB C1855769

Connections:
+3.3V_D: C21.1, C22.1, U5.16 (VDD), U17.16 (VDD); also elsewhere on the board
/UART Select/CTS_N_FT2232H: U5.12 (D4); also elsewhere on the board
/UART Select/RTS_N_FT2232H: U5.9 (D3); also elsewhere on the board
/UART Select/RXD_FT2232H: U5.7 (D2); also elsewhere on the board
/UART Select/TXD_FT2232H: U5.4 (D1); also elsewhere on the board
CTS_N_PIN: U5.13 (S4B); also elsewhere on the board
CTS_N_WIFI: U17.9 (D3); also elsewhere on the board
GND: C21.2, C22.2, U5.8 (GND), U5.15 (*EN), U17.8 (GND), U17.15 (*EN); also elsewhere on the board
MCU_RXD0: U17.6 (S2B); also elsewhere on the board
MCU_TXD0: U17.3 (S1B); also elsewhere on the board
unnamed: U5.11 (D3A), U17.11 (D3A)
unnamed: U5.2 (S1A), U17.2 (S1A)
unnamed: U5.5 (S2A), U17.5 (S2A)
unnamed: U5.14 (S4A), U17.14 (S4A)
RTS_N_PIN: U5.10 (D3B); also elsewhere on the board
RTS_N_WIFI: U17.12 (D4); also elsewhere on the board
RXD_PIN: U5.6 (S2B); also elsewhere on the board
RXD_WIFI: U17.4 (D1); also elsewhere on the board
TXD_PIN: U5.3 (S1B); also elsewhere on the board
TXD_WIFI: U17.7 (D2); also elsewhere on the board
UART_SEL: U5.1 (SEL), U17.1 (SEL); also elsewhere on the board

Notes on the sheet:
Charge Injection:3.5pC(typ)
PIN Header
FT2232H
SEL, *EN Weak pull down:6MΩ(typ)
UART Select
UART_SEL(DPSW 3)
ESP-12F
RP2350A
1(default)
接続先

Board: 6 copper layers, 100.0 x 100.0 mm, 310 parts (164 on the bottom side), 192 nets.

File FlexLogic_EVB_BOM.csv:

"Reference","Value","Do Not Place","Exclude from BOM","Exclude from Board","Exclude from Simulation","MANUFACTURER_PART_NUMBER","Qty"
"D2","XL-1005UBC","","","","","XL-1005UBC","1"
"R7","3.6k","","","","","WR02X362JAL","1"
"R17,R18,R28,R35,R63,R64,R71","2.2k","","","","","WR02X222JAL","7"
"J2,J3,J4,J5","WJ126V-5.0-2P","","","","","WJ126V-5.0-2P","4"
"IC3","W25Q16JVUXIQ","","","","","W25Q16JVUXIQ","1"
"U12","TMUX1574DYYR","","","","","TMUX1574DYYR","1"
"U2","TLV803SDBZR","","","","","TLV803SDBZR","1"
"C20,C28,C33,C36,C49,C54,C66,C74,C85,C88,C91","1uF","","","","","TCC0402X5R105M6R3AT","11"
"C18,C19,C47,C48,C72,C73","30pF","","","","","TCC0201COG300J500ZT","6"
"IC2","SL2.1s","","","","","SL2.1S","1"
"S1","SKRPACE010","","","","","SKRPACE010","1"
"U1","RT5752BHGJ5","","","","","RT5752BHGJ5","1"
"U3,U6,U10","RQ12000160","","","","","RQ12000160","3"
"U5","RP2040","","","","","RP2040","1"
"R62,R70","100","","","","","RC0201JR-07100RL","2"
"R3,R13,R24,R25,R29,R48,R49,R50,R51,R53,R55,R56,R58,R60","10k","DNP","","","","RC0201FR-0710KL","14"
"R16,R21,R30,R34,R37,R41,R42,R45","1M","","","","","RC0201FR-071ML","8"
"R6","1k","","","","","RC0201FR-071KL","1"
"R9,R14,R15,R22,R32,R46,R47,R59,R61","30","","","","","RC-01W30R0FT","9"
"R19,R20,R31,R33,R38,R39,R40,R43,R44,R67,R68,R69,R72,R73,R74,R75","240","","","","","RC-01W241JT","16"
"R4","100k","","","","","RC-01W104JT","1"
"J13","PH-2A","","","","","PH-2A","1"
"IC5","MTS4P","","","","","MTS4P","1"
"IC1","MT9700","","","","","MT9700","1"
"D1","LESD5D5-0CT1G","","","","","LESD5D5.0CT1G-ES","1"
"IC4","LCMXO2-1200HC-4SG32I","","","","","LCMXO2-1200HC-4SG32I","1"
"C3,C4,C5","22uF","","","","","HGC0603R5226M100NTHJ","3"
"C2,C7,C15,C16,C17,C68","10uF","","","","","HGC0402R5106M100NTEJ","6"
"L1,L2,L4,L5,L6,L7,L8,L9","HCB1005KF-121T20","","","","","HCB1005KF-121T20","8"
"J1","GT-USB-7010ASV","","","","","GT-USB-7010ASV","1"
"C1,C6,C8,C9,C10,C11,C12,C13,C14,C21,C22,C23,C24,C25,C26,C27,C29,C30,C31,C34,C35,C37,C38,C39,C40,C41,C42,C43,C44,C45,C46,C50,C51,C53,C55,C56,C57,C58,C59,C60,C61,C62,C63,C64,C65,C67,C69,C70,C71,C75,C76,C77,C78,C80,C81,C82,C83,C84,C86,C87,C89,C90,C92,C93","0.1uF","","","","","GRM033R61E104KE14D","64"
"L3","1.5uH","","","","","FTC252012S1R5MBCA","1"
"U8","FT2232HL","","","","","FT2232HL","1"
"SW1","DSWB02LHGETB","","","","","DSWB02LHGETB","1"
"U4,U7","ADS1115IDGSR","","","","","ADS1115IDGSR","2"
"U9","93LC56BT-I","","","","","93LC56BT-I","1"
"J12","1.0-3PWB","","","","","1.0-3PWB","1"
"R10,R11","5.1k","","","","","0201WMF5101TEE","2"
"R2,R5,R26,R27,R36","4.7k","","","","","0201WMF4701TEE","5"
"R8","22k","","","","","0201WMF2202TEE","1"
"R52","12k","","","","","0201WMF1202TEE","1"
"R65","0","","","","","0201WMF0000TEE","1"
"C32,C52","0.01uF","","","","","0201B103K250NT","2"
"TP3,TP9,TP10,TP12","TestPoint","","","","","","4"
"J10","Conn_01x04","","","","","","1"
"J6,J7,J8,J9,J11","Conn_02x03_Odd_Even","","","","","","5"

## Commit log

2026-01-13 1S commit
